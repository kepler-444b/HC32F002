# Keil uVision project HC32F002.uvprojx, settings and files
target HC32F002 (6240000::V6.24::ARMCLANG)
  device: HC32F002C4PZ HDSC
  pack: HDSC.HC32F002.1.0.0
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\..\mcu\common;..\Source;..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4800
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f002.s
    ../../mcu/common/: system_hc32f002.c interrupts_hc32f002.c
  group App_main
    ../source/: main.c
  group driver
    ../../driver/src/: ddl.c sysctrl.c adc.c atim3.c btim.c ctrim.c flash.c gpio.c gtim.c i2c.c iwdt.c lpm.c lpuart.c lvd.c spi.c wwdt.c
    ../../driver/inc/: adc.h atim3.h btim.h ctrim.h ddl.h flash.h gpio.h gtim.h i2c.h iwdt.h lpm.h lpuart.h lvd.h spi.h sysctrl.h wwdt.h
  group APP
    ../Source/App/: app_timer.c app_timer.h app_base.c app_base.h app_protocol.c app_protocol.h
  group Bsp
    ../Source/Bsp/: bsp_gpio.c bsp_gpio.h bsp_usart.c bsp_usart.h bsp_pcb.c bsp_pcb.h bsp_adc.c bsp_adc.h bsp_flash.c bsp_flash.h
    ../Source/Bsp/bsp_595/: bsp_595.c bsp_595.h
  group README
    ../: readme.txt
  group Rtt
    ../Source/Rtt/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group Dev
    ../Source/Dev/: dev_manager.c dev_manager.h dev_panel.c dev_panel.h dev_config.c dev_config.h
software components: CMSIS:CORE 6.1.1
