# IAR project lpuart_rx_tx_poll.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lpuart_rx_tx_poll.hex
  ILINK.IlinkOutputFile: lpuart_rx_tx_poll.out
  ILINK.IlinkIcfFile: HC32F002.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\utility
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: lpuart_rx_tx_poll.srec
  group common
    ../../../../mcu/common/: system_hc32f002.c interrupts_hc32f002.c
    ./: startup_hc32f002.s
    ../../../../driver/src/: ddl.c
  group driver
    ../../../../driver/src/: sysctrl.c lpuart.c lpm.c gpio.c sysctrl.c
  group source
    ../source/: main.c
  group README
    ../: readme.txt
