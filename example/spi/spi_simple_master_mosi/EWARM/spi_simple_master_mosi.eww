<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\spi_simple_master_mosi.ewp</path>
  </project>
  <batchBuild/>
</workspace>


