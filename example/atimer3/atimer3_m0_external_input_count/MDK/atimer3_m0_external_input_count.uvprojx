# Keil uVision project atimer3_m0_external_input_count.uvprojx, settings and files
target atimer3_m0_external_input_count_Release (6160000::V6.16::ARMCLANG)
  device: HC32F002D4PZ HDSC
  pack: HDSC.HC32F002.1.0.0
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4800) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: atimer3_m0_external_input_count +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4800
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f002.s
    ../../../../mcu/common/: system_hc32f002.c interrupts_hc32f002.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c atim3.c gpio.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.5.0
