# Keil uVision project gpio_inout.uvprojx, settings and files
target gpio_inout_Release (6240000::V6.24::ARMCLANG)
  device: HC32F002C4PZ HDSC
  pack: HDSC.HC32F002.1.0.0
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: A13_yanshi3 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4800
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f002.s
    ../../../../mcu/common/: system_hc32f002.c interrupts_hc32f002.c
  group source
    ../source/: main.c sys.c led.c key.c xunSub.c RelayApp.c
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c gpio.c atim3.c flash.c lpuart.c wwdt.c adc.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 6.1.1
